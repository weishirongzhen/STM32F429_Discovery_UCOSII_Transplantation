# Keil uVision project stm32f429_ucosii.uvprojx, settings and files
target stm32f429_ucos (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f429_ucosii
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\User;..\..\Libraries\CMSIS;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\uC-CPU;..\uC-CPU\ARM-Cortex-M4\RealView;..\uC-LIB;..\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\uCOS-II\Ports;..\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\uCOS-II\Source
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CMSIS
    ../../Libraries/CMSIS/: startup_stm32f429_439xx.s
  group STM32_StdLib
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group uC-LIB
    ../uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC-CPU
    ../uC-CPU/: cpu_core.c
    ../uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group uCOS-II-SOURCE
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II-PORT
    ../uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_a.asm os_cpu_c.c os_dbg.c
